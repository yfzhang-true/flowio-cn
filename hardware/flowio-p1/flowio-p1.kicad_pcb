# Repository yfzhang-true/flowio-cn

File README.md:

# FLOWIO-CN

**Open-source pneumatic soft robotics control platform** — from 4-layer PCB to digital twin.

## What is this?

FLOWIO-CN is a fully open-source, production-ready pneumatic soft robotics control platform. It's the Chinese domestic alternative to MIT's FlowIO, designed for B2B rehabilitation glove manufacturers (¥300-500/kit including board + firmware + SDK).

**One person, AI-driven, from zero to product in 3 days.**

## Architecture

```
┌─────────────────────────────────────────────────┐
│  Digital Twin (Web)                             │
│  3D exploded view · airflow/current viz        │
│  Real-time telemetry · simulation lab          │
├─────────────────────────────────────────────────┤
│  Python SDK · BLE GATT · Serial CLI            │
├─────────────────────────────────────────────────┤
│  ESP32-S3 Firmware (ESP-IDF + FreeRTOS)       │
│  pn_core (platform-independent C)              │
│  TCA9548A I2C mux · WS2812 · 8× valve PWM    │
├─────────────────────────────────────────────────┤
│  4-Layer PCB (90×75mm) · FreeCAD enclosure    │
│  JLC fab-ready · via-in-pad Type VII          │
└─────────────────────────────────────────────────┘
```

## Quick Start

### Digital Twin (no hardware needed)
```bash
cd firmware/twin
"E:/Program Files/KiCad/10.0/bin/python.exe" server.py
# Open http://localhost:8000
```

### Flash Firmware
```bash
cd firmware
idf.py flash monitor
```

### Python SDK
```python
from flowio_sdk import FlowIO
device = FlowIO("COM3")
device.inflate(port=1, pwm=180)
device.hold(port=1)
```

## Repository Structure

| Directory | Description |
|---|---|
| `firmware/` | ESP32-S3 firmware + digital twin + tests |
| `hardware/flowio-p1/` | KiCad PCB project + fab package |
| `sdk/python/` | flowio_sdk Python package |
| `book/` | LaTeX book source (94 pages, Chinese) |
| `docs/superpowers/` | Engineering specs & plans |
| `enclosure/` | FreeCAD parametric case |

## Key Metrics

| Metric | Value |
|---|---|
| PCB layers | 4 (F: signal · In1: GND · In2: power split · B: signal) |
| DRC violations | **0** (from 146 initial) |
| Host tests | 33/33 ✅ |
| Web app tests | 44/44 ✅ |
| API tests | 50/50 ✅ |
| BLE services | 4 (Command · Telemetry · Config · DeviceInfo) |
| Book | 94 pages · 14 chapters · 31 bib entries |

## Documentation

- [BRINGUP Guide](firmware/BRINGUP.md) — Hardware bring-up checklist
- [API v1.2](firmware/twin/API.md) — HTTP interface spec
- [BLE Interface](firmware/twin/BLE.md) — GATT service/characteristic spec
- [Book PDF](book/build/main.pdf) — 《气动软体机器人自研实战》(in progress)

## License

- **Code**: MIT License
- **Hardware (PCB/enclosure)**: CERN-OHL-S v2
- **Documentation/Book**: CC BY-NC-ND 4.0

## Author

**张越飞 (Zhang Yuefei)** — Embedded Software Engineer
- GitHub: [@yfzhang-true](https://github.com/yfzhang-true)
- Email: yuefeizzz@163.com

---

*Built with AI-driven development methodology. Every spec, plan, test, and commit is documented in `docs/superpowers/`.*

## KiCad design hardware/flowio-p1/flowio-p1.kicad_pcb

Parts:
C1, C9, C17: 10uF; C1206; LCSC C13585
C2, C5, C6, C10, C11, C12, C13, C15, C16, C18: 100nF; C_0603_1608Metric; LCSC C1591
C3: 2.2nF; C_0603_1608Metric; LCSC C33353
C4: 22pF; C_0603_1608Metric; LCSC C1653
C7, C8: 100uF; C1206; LCSC C15008
C14: 1uF; C_0603_1608Metric; LCSC C15849
D2, D3: SS34; SMA_L4.3-W2.6-LS5.2-RD; LCSC C8678
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15: SS14; SMA_L4.2-W2.6-LS5.0-RD_1; LCSC C2480
J1: USB-C PWR; USB-C_SMD-TYPE-C-31-M-12_1; LCSC C165948
J2: USB-C; TYPE-C-SMD_TYPE-C-6P_1; LCSC C456012
J5, J6, J7, J8, J9: XH-4P; CONN-TH_4P-P2.54_6173868; LCSC C5359632
J10, J11, J12, J13, J14, J15, J16, J17, J20, J21, J22: VALVE; CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT; LCSC C7429671
J18: DEBUG-UART; CONN-TH_4P-P2.54_6173868; LCSC C5359632
J19: DEBUG-GPIO; CONN-TH_4P-P2.54_6173868; LCSC C5359632
J23: PUMP; CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT; LCSC C7429671
L1: 6.8uH; IND-SMD_L10.2-W10.0; LCSC C167253
LED1: WS2812B; LED-SMD_4P-L5.0-W5.0-BL_XL-5050RGBC; LCSC C2843785
LED2: PWR; LED-SMD_L1.6-W0.8-R-RD; LCSC C2286
LED3: USER; LED0603-RD; LCSC C2288
LED4: TX; LED0603-RD-YELLOW; LCSC C125100
LED5: RX; LED0603-RD-YELLOW; LCSC C125100
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q13, Q14, Q15, Q16: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC C20917
Q11, Q12: SS8050; SOT-23-3_L3.0-W1.3-P1.90-LS2.5-BR; LCSC C181160
R1, R2, R63, R64: 5.1k; R0603; LCSC C23186
R3: 100k; R0603; LCSC C14675
R4, R6, R7, R13, R14, R15, R16, R21, R22, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R47, R48, R49, R50, R51, R52, R53, R54, R59, R60, R61, R62: 10k; R0603; LCSC C25804
R5: 3.24k; R0603; LCSC C22994
R8, R9: 4.7k; R0603; LCSC C23162
R10, R11, R19, R20, R23, R24, R25, R26, R39, R40, R41, R42, R43, R44, R45, R46, R55, R56, R57, R58: 1k; R0603; LCSC C21190
R12: 330R; R0603; LCSC C23138
R17, R18: 22R; R0603; LCSC C23345
SW1: RST; SW-SMD_ST-1185S; LCSC C589191
SW2: BOOT; SW-SMD_ST-1185S; LCSC C589191
SW3: USER; SW-SMD_ST-1185S; LCSC C589191
TP1: +3V3; TestPoint_Pad_D1.0mm
TP2: +5V; TestPoint_Pad_D1.0mm
TP3, TP4, TP5, TP6: GND; TestPoint_Pad_D1.0mm
TP7: I2C_SDA; TestPoint_Pad_D1.0mm
TP8: I2C_SCL; TestPoint_Pad_D1.0mm
TP9: GATE1; TestPoint_Pad_D1.0mm
TP10: DRV1; TestPoint_Pad_D1.0mm
TP11: PH; TestPoint_Pad_D1.0mm
TP12: EN; TestPoint_Pad_D1.0mm
TP13: DRV_PUMP; TestPoint_Pad_D1.0mm
U1: ESP32-S3-WROOM-1-N16R8; WIRELM-SMD_ESP32-S3-WROOM-1; LCSC C2913202
U2: TCA9548APWR; TSSOP-24_L7.8-W4.4-P0.65-LS6.4-BL; LCSC C130026
U3: TPS54331DR; SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL; LCSC C9865
U4: CH340K; ESOP-10_L4.9-W3.9-P1.00-LS6.2-BL-EP; LCSC C968586
U5, U7: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; LCSC C7519
U6: XGZP6897D; XGZP6897D-SOP8-W7.96-P2.54

Connections:
+3V3: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C18.1, J5.1, J6.1, J7.1, J8.1, J9.1, J18.4, J19.2, L1.2, LED1.1 (VDD), LED2.1 (A), LED4.1 (-), LED5.1 (-), R4.1, R7.1, R8.1, R9.1, R13.1, R14.1, R16.1, R21.1, R22.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, TP1.1, U1.2 (3V3), U2.24 (VCC), U4.7 (VCC), U4.10 (V3), U6.2 (VDD)
+5V: C1.1, C2.1, C15.1, C16.1, C17.1, D2.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), J1.A4B9 (VBUS), J1.B4A9 (VBUS), J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J20.1, J21.1, J22.1, J23.1, R3.1, TP2.1, U3.2 (VIN), U7.5
BOOT: C5.1, Q12.3 (C), R13.2, SW2.1, U1.27 (IO0), U3.1 (BOOT)
BTN_USER: J19.4, R27.2, SW3.1, U1.22 (IO14)
BUCK_EN: R3.2, U3.3 (EN)
BUCK_SS: C6.1, U3.4 (SS)
CC1: J2.A5 (CC1), R1.1
CC2: J2.B5 (CC2), R2.1
CH_RX: R11.1, R26.2, U4.9 (RXD)
CH_TX: R10.1, R25.2, U4.8 (TXD)
COMP: R6.1, U3.6 (COMP)
COMP_RC: C3.1, C4.1, R6.2
DRV1: D4.2 (A), J10.2, Q3.3 (D), TP10.1
DRV2: D5.2 (A), J11.2, Q4.3 (D)
DRV3: D6.2 (A), J12.2, Q5.3 (D)
DRV4: D7.2 (A), J13.2, Q6.3 (D)
DRV5: D8.2 (A), J14.2, Q7.3 (D)
DRV6: D9.2 (A), J15.2, Q8.3 (D)
DRV7: D10.2 (A), J16.2, Q9.3 (D)
DRV8: D11.2 (A), J17.2, Q10.3 (D)
DRV_F: D14.2 (A), J22.2, Q15.3 (D)
DRV_PUMP: D15.2 (A), J23.2, Q16.3 (D), TP13.1
DRV_S: D12.2 (A), J20.2, Q13.3 (D)
DRV_V: D13.2 (A), J21.2, Q14.3 (D)
DTR: R19.1, U4.4 (DTR#)
DTR_R: Q11.1 (B), R19.2, R21.2
EN: C14.1, Q11.3 (C), R7.2, SW1.1, TP12.1, U1.3 (EN)
FB: R4.2, R5.1, U3.5 (VSENSE)
GATE1: Q3.1 (G), R39.2, R47.1, TP9.1
GATE2: Q4.1 (G), R40.2, R48.1
GATE3: Q5.1 (G), R41.2, R49.1
GATE4: Q6.1 (G), R42.2, R50.1
GATE5: Q7.1 (G), R43.2, R51.1
GATE6: Q8.1 (G), R44.2, R52.1
GATE7: Q9.1 (G), R45.2, R53.1
GATE8: Q10.1 (G), R46.2, R54.1
GATE_F: Q15.1 (G), R57.2, R61.1
GATE_PUMP: Q16.1 (G), R58.2, R62.1
GATE_S: Q13.1 (G), R55.2, R59.1
GATE_V: Q14.1 (G), R56.2, R60.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D3.2 (A), J1.1 (EH), J1.2 (EH), J1.3 (EH), J1.4 (EH), J1.A1B12 (GND), J1.B1A12 (GND), J2.7 (EH), J2.A12 (GND), J2.B12 (GND), J5.2, J6.2, J7.2, J8.2, J9.2, J18.2, J19.3, LED1.3 (GND), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (E), Q12.2 (E), Q13.2 (S), Q14.2 (S), Q15.2 (S), Q16.2 (S), R1.2, R2.2, R5.2, R15.1, R23.2, R24.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, SW1.2, SW2.2, SW3.2, TP3.1, TP4.1, TP5.1, TP6.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.1 (A0), U2.2 (A1), U2.12 (GND), U2.21 (A2), U3.7 (GND), U4.3 (GND), U4.11 (EP), U5.2, U6.8 (GND), U7.2
I2C_SCL: R9.2, TP8.1, U1.17 (IO9), U2.22 (SCL), U6.7 (SCL)
I2C_SDA: R8.2, TP7.1, U1.12 (IO8), U2.23 (SDA), U6.6 (SDA)
IO4: R39.1, U1.4 (IO4)
IO5: R40.1, U1.5 (IO5)
IO6: R41.1, U1.6 (IO6)
IO7: R42.1, U1.7 (IO7)
IO10: R43.1, U1.18 (IO10)
IO11: R44.1, U1.19 (IO11)
IO12: R45.1, U1.20 (IO12)
IO15: R55.1, U1.8 (IO15)
IO16: R56.1, U1.9 (IO16)
IO17: R57.1, U1.10 (IO17)
IO18: R58.1, U1.11 (IO18)
IO21: R46.1, U1.23 (IO21)
IO48: R12.1, U1.25 (IO48)
LED_PWR_K: LED2.2 (K), R23.1
LED_RX_K: LED5.2 (+), R26.1
LED_TX_K: LED4.2 (+), R25.1
LED_USER: J19.1, LED3.1 (K), U1.21 (IO13)
LED_USER_K: LED3.2 (A), R24.1
P5_CC1: J1.A5 (CC1), R63.1, U7.1, U7.6
P5_CC2: J1.B5 (CC2), R64.1, U7.3, U7.4
PH: C5.2, D3.1 (K), L1.1, TP11.1, U3.8 (PH)
RGB_R: LED1.4 (DIN), R12.2
RTS: R20.1, U4.6 (RTS#)
RTS_R: Q12.1 (B), R20.2, R22.2
S1_SCL: J5.4, R34.2, U2.5 (SC0)
S1_SDA: J5.3, R29.2, U2.4 (SD0)
S2_SCL: J6.4, R35.2, U2.7 (SC1)
S2_SDA: J6.3, R30.2, U2.6 (SD1)
S3_SCL: J7.4, R36.2, U2.9 (SC2)
S3_SDA: J7.3, R31.2, U2.8 (SD2)
S4_SCL: J8.4, R37.2, U2.11 (SC3)
S4_SDA: J8.3, R32.2, U2.10 (SD3)
S5_SCL: J9.4, R38.2, U2.14 (SC4)
S5_SDA: J9.3, R33.2, U2.13 (SD4)
STRAP3: R14.2, U1.15 (IO3)
STRAP45: R15.2, U1.26 (IO45)
STRAP46: R16.2, U1.16 (IO46)
TCA_RST: R28.2, U2.3 (RESET#)
UART_RX: J18.3, R10.2, U1.36 (RXD0)
UART_TX: J18.1, R11.2, U1.37 (TXD0)
USB_DN: R18.1, U5.3, U5.4
USB_DN_CH: R18.2, U4.2 (UD-)
USB_DP: R17.1, U5.1, U5.6
USB_DP_CH: R17.2, U4.1 (UD+)
USB_VBUS: D2.2 (A), J2.A9 (VBUS), J2.B9 (VBUS), U5.5

Notes on the sheet:
USB-C 5A 供电 (J1: Rd 5.1k x2 + U7 ESD) + TPS54331 Buck
USB-UART CH340K + SS8050 自动下载
ESP32-S3-WROOM-1-N16R8 主控 + Strapping
TCA9548A 五通道 I2C 传感链 + U6 XGZP6897D 板载压力传感
12 路 AO3400A 驱动: 8x 阀 + S/V/F 主阀 + 泵 (1f-β, XH-2P 插座 J10-J23)
调试排针 + 测试点

Board: 4 copper layers, 100.0 x 80.0 mm, 164 parts (0 on the bottom side), 88 nets.

Other parts of the board:
HA: MountingHole_3.2mm_M3
HB: MountingHole_3.2mm_M3
HC: MountingHole_3.2mm_M3
HD: MountingHole_3.2mm_M3

File hardware/flowio-p1/bom.csv:

"Refs","Value","Footprint","Qty","DNP"
"C1","10uF","JLC-MCP:C1206","1",""
"C2","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C3","2.2nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C4","22pF","Capacitor_SMD:C_0603_1608Metric","1",""
"C5","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C6","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C7","100uF","JLC-MCP:C1206","1",""
"C8","100uF","JLC-MCP:C1206","1",""
"C9","10uF","JLC-MCP:C1206","1",""
"C10","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C11","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C12","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C13","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C14","1uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C15","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C16","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"C17","10uF","JLC-MCP:C1206","1",""
"C18","100nF","Capacitor_SMD:C_0603_1608Metric","1",""
"D2","SS34","JLC-MCP:SMA_L4.3-W2.6-LS5.2-RD","1",""
"D3","SS34","JLC-MCP:SMA_L4.3-W2.6-LS5.2-RD","1",""
"D4","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D5","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D6","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D7","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D8","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D9","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D10","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D11","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D12","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D13","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D14","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"D15","SS14","JLC-MCP:SMA_L4.2-W2.6-LS5.0-RD_1","1",""
"J1","USB-C PWR","JLC-MCP:USB-C_SMD-TYPE-C-31-M-12_1","1",""
"J2","USB-C","JLC-MCP:TYPE-C-SMD_TYPE-C-6P_1","1",""
"J5","XH-4P","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J6","XH-4P","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J7","XH-4P","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J8","XH-4P","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J9","XH-4P","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J10","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J11","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J12","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J13","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J14","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J15","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J16","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J17","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J18","DEBUG-UART","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J19","DEBUG-GPIO","JLC-MCP:CONN-TH_4P-P2.54_6173868","1",""
"J20","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J21","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J22","VALVE","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"J23","PUMP","JLC-MCP:CONN-SMD_2P-P2.54_MEGASTAR_ZX-XH2.54-2PWT","1",""
"L1","6.8uH","JLC-MCP:IND-SMD_L10.2-W10.0","1",""
"LED1","WS2812B","JLC-MCP:LED-SMD_4P-L5.0-W5.0-BL_XL-5050RGBC","1",""
"LED2","PWR","JLC-MCP:LED-SMD_L1.6-W0.8-R-RD","1",""
"LED3","USER","JLC-MCP:LED0603-RD","1",""
"LED4","TX","JLC-MCP:LED0603-RD-YELLOW","1",""
"LED5","RX","JLC-MCP:LED0603-RD-YELLOW","1",""
"Q3","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q4","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q5","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q6","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q7","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q8","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q9","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q10","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q11","SS8050","JLC-MCP:SOT-23-3_L3.0-W1.3-P1.90-LS2.5-BR","1",""
"Q12","SS8050","JLC-MCP:SOT-23-3_L3.0-W1.3-P1.90-LS2.5-BR","1",""
"Q13","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q14","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q15","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"Q16","AO3400A","JLC-MCP:SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR","1",""
"R1","5.1k","JLC-MCP:R0603","1",""
"R2","5.1k","JLC-MCP:R0603","1",""
"R3","100k","JLC-MCP:R0603","1",""
"R4","10k","JLC-MCP:R0603","1",""
"R5","3.24k","JLC-MCP:R0603","1",""
"R6","10k","JLC-MCP:R0603","1",""
"R7","10k","JLC-MCP:R0603","1",""
"R8","4.7k","JLC-MCP:R0603","1",""
"R9","4.7k","JLC-MCP:R0603","1",""
"R10","1k","JLC-MCP:R0603","1",""
"R11","1k","JLC-MCP:R0603","1",""
"R12","330R","JLC-MCP:R0603","1",""
"R13","10k","JLC-MCP:R0603","1",""
"R14","10k","JLC-MCP:R0603","1",""
"R15","10k","JLC-MCP:R0603","1",""
"R16","10k","JLC-MCP:R0603","1",""
"R17","22R","JLC-MCP:R0603","1",""
"R18","22R","JLC-MCP:R0603","1",""
"R19","1k","JLC-MCP:R0603","1",""
"R20","1k","JLC-MCP:R0603","1",""
"R21","10k","JLC-MCP:R0603","1",""
"R22","10k","JLC-MCP:R0603","1",""
"R23","1k","JLC-MCP:R0603","1",""
"R24","1k","JLC-MCP:R0603","1",""
"R25","1k","JLC-MCP:R0603","1",""
"R26","1k","JLC-MCP:R0603","1",""
"R27","10k","JLC-MCP:R0603","1",""
"R28","10k","JLC-MCP:R0603","1",""
"R29","10k","JLC-MCP:R0603","1",""
"R30","10k","JLC-MCP:R0603","1",""
"R31","10k","JLC-MCP:R0603","1",""
"R32","10k","JLC-MCP:R0603","1",""
"R33","10k","JLC-MCP:R0603","1",""
"R34","10k","JLC-MCP:R0603","1",""
"R35","10k","JLC-MCP:R0603","1",""
"R36","10k","JLC-MCP:R0603","1",""
"R37","10k","JLC-MCP:R0603","1",""
"R38","10k","JLC-MCP:R0603","1",""
"R39","1k","JLC-MCP:R0603","1",""
"R40","1k","JLC-MCP:R0603","1",""
"R41","1k","JLC-MCP:R0603","1",""
"R42","1k","JLC-MCP:R0603","1",""
"R43","1k","JLC-MCP:R0603","1",""
"R44","1k","JLC-MCP:R0603","1",""
"R45","1k","JLC-MCP:R0603","1",""
"R46","1k","JLC-MCP:R0603","1",""
"R47","10k","JLC-MCP:R0603","1",""
"R48","10k","JLC-MCP:R0603","1",""
"R49","10k","JLC-MCP:R0603","1",""
"R50","10k","JLC-MCP:R0603","1",""
"R51","10k","JLC-MCP:R0603","1",""
"R52","10k","JLC-MCP:R0603","1",""
"R53","10k","JLC-MCP:R0603","1",""
"R54","10k","JLC-MCP:R0603","1",""
"R55","1k","JLC-MCP:R0603","1",""
"R56","1k","JLC-MCP:R0603","1",""
"R57","1k","JLC-MCP:R0603","1",""
"R58","1k","JLC-MCP:R0603","1",""
"R59","10k","JLC-MCP:R0603","1",""
"R60","10k","JLC-MCP:R0603","1",""
"R61","10k","JLC-MCP:R0603","1",""
"R62","10k","JLC-MCP:R0603","1",""
"R63","5.1k","JLC-MCP:R0603","1",""
"R64","5.1k","JLC-MCP:R0603","1",""
"SW1","RST","JLC-MCP:SW-SMD_ST-1185S","1",""
"SW2","BOOT","JLC-MCP:SW-SMD_ST-1185S","1",""
"SW3","USER","JLC-MCP:SW-SMD_ST-1185S","1",""
"TP1","+3V3","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP2","+5V","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP3","GND","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP4","GND","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP5","GND","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP6","GND","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP7","I2C_SDA","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP8","I2C_SCL","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP9","GATE1","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP10","DRV1","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP11","PH","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP12","EN","TestPoint:TestPoint_Pad_D1.0mm","1",""
"TP13","DRV_PUMP","TestPoint:TestPoint_Pad_D1.0mm","1",""
"U1","ESP32-S3-WROOM-1-N16R8","JLC-MCP:WIRELM-SMD_ESP32-S3-WROOM-1","1",""
"U2","TCA9548APWR","JLC-MCP:TSSOP-24_L7.8-W4.4-P0.65-LS6.4-BL","1",""
"U3","TPS54331DR","JLC-MCP:SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL","1",""
"U4","CH340K","JLC-MCP:ESOP-10_L4.9-W3.9-P1.00-LS6.2-BL-EP","1",""
"U5","USBLC6-2SC6","JLC-MCP:SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL","1",""
"U6","XGZP6897D","LOCAL:XGZP6897D-SOP8-W7.96-P2.54","1",""
"U7","USBLC6-2SC6","JLC-MCP:SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL","1",""

Notices in the files:
README.md:
License: MIT
License: CERN OHL-S
License: CC BY-NC-ND 4.0
